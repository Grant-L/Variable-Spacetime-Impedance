* Variable Spacetime Impedance (AVE) - SPICE Netlist
* Element: Helium-4 (Z=2, A=4)
* Auto-generated topological mutual impedance array
* Nodes: 4

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_5 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_6 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Perform a broadband AC sweep from 1 MHz to 1 GHz to ping macro-resonance
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
