* Variable Spacetime Impedance (AVE) - SPICE Netlist
* Element: Hydrogen-1 (Z=1, A=1)
* Auto-generated topological mutual impedance array
* Nodes: 1

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1

X_NUC_1 NODE_1 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Perform a broadband AC sweep from 1 MHz to 1 GHz to ping macro-resonance
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
